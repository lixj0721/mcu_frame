# Keil uVision project actbal.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: N32G031K8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: actbal
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../../../app/: led_app.c main.c
  group adp
    ../../../adp/n32g031/adp/src/: adp_n32g031_core.c
