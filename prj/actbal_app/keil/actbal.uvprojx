# Keil uVision project actbal.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G031K8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: actbal
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SYSCLK_SRC=SYSCLK_USE_HSE_PLL, HSE_VALUE=8000000
  c include: ..\usr;..\..\..\adp\n32g031\std\inc;..\..\..\adp\n32g031\adp\inc;..\..\..\app;..\..\..\bsp\bms;..\..\..\inf;..\..\..\mid;..\..\..\mid\protocol;..\..\..\tool;..\..\..\adp\n32g031\adp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../../../app/: led_app.c main.c
  group adp
    ../../../adp/n32g031/adp/src/: adp_n32g031_core.c adp_n32g031_flash.c adp_n32g031_gpio.c adp_n32g031_iic.c adp_n32g031_uart.c
    ../../../adp/: adp_config.c
  group prj
    ../usr/: usr_app.c
  group tool
    ../../../tool/: smallprint.c toolkit.c
  group lib
    ../../../adp/n32g031/std/src/: misc.c n32g031_adc.c n32g031_beeper.c n32g031_comp.c n32g031_crc.c n32g031_dbg.c n32g031_dma.c n32g031_exti.c n32g031_flash.c n32g031_gpio.c n32g031_hdiv.c n32g031_i2c.c n32g031_iwdg.c n32g031_lptim.c n32g031_lpuart.c n32g031_opamp.c n32g031_pwr.c n32g031_rcc.c n32g031_rtc.c n32g031_spi.c n32g031_sqrt.c n32g031_tim.c n32g031_usart.c n32g031_wwdg.c system_n32g031.c
    ../../../adp/n32g031/startup/: startup_n32g031.s
  group inf
    ../../../inf/: inf_conf.c uart_inf.c
  group mid
    ../../../mid/: io_op.c debug.c task_scheduler.c
