# Keil uVision project virtual_cell.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: virtual_cell
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: HSE_VALUE=8000000, STM32F10X_HD, USE_STDPERIPH_DRIVER,
  c include: ..\..\..\adp\stm32f1\adp\inc;..\..\..\adp\stm32f1\std\inc;..\..\..\app;..\..\..\bsp\tool;..\..\..\mid;..\usr;..\..\..\tool;..\..\..\adp\stm32f1\adp;..\..\..\dev\logic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../../../app/: led_app.c main.c
  group adp
    ../../../adp/stm32f1/adp/src/: adp_stm32f1_core.c adp_stm32f1_gpio.c adp_stm32f1_iic.c
    ../../../adp/stm32f1/adp/: adp_config.c
  group mid
    ../../../mid/: io_op.c task_scheduler.c
  group prj
    ../usr/: mcp_test.c
  group tool
    ../../../adp/stm32f1/std/src/: stm32f10x_dma.c stm32f10x_rtc.c
    ../../../tool/: toolkit.c
  group stdlib
    ../../../adp/stm32f1/std/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ../../../adp/stm32f1/std/startup/arm/: startup_stm32f10x_hd.s
  group dev
    ../../../dev/logic/: dev_mcp4551_inf.c
